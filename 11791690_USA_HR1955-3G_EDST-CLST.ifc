Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [COBie2.4DesignDeliverable], RevitIdentifiers [VersionGUID: 143e36e4-8f02-45f5-b55f-a74ccce528e2, NumberOfSaves: 1]
File name: 0001
Time: 2024-09-05T14:36:36+01:00
Written by: ODA SDAI 23.12
Made in: Autodesk Revit 24.0.20.20 (ENU) - IFC 24.0.20.20

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Pset_ProductRequirements - Category: Project Information

# IfcBuildingElementProxy: 11791690_USA_HR1955-3G_EDST-CLST:25195581_USA_11791690_HR1955-3G_EDST-CLST, (2)
In: Default
Type - Material: z_Miele_Design_CLST, z_Miele_Design_Glass Black, z_Miele_Design_Cast, z_Miele_Design_OBSW, <Unnamed>, z_Miele_Connection_Gas, z_Miele_Connection_Electric, z_Miele_Connection_Water_IN, z_Miele_Design_Steel_Chrom
Type - Pset_ProductRequirements - Category: Specialty Equipment
Type - Pset_ProvisionForVoid - Width: 1220 mm; Height: 980 mm; Depth: 702 mm
Classification: E1090320 Uniformat (Uniformat)
Pset_BuildingElementProxyCommon - Reference: 25195581_USA_11791690_HR1955-3G_EDST-CLST; sets with these values: 2

# IfcDistributionPort, Port_360021_1
Description: Flow; FlowDirection: SOURCEANDSINK
